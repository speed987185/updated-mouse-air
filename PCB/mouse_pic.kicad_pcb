# Repository speed987185/updated-mouse-air

File README.md:

# updated-mouse-air
a mouse for a blueprint submit
this a mouse project made for blueprint submission you can create your own mouse using my repo this contain all the step file :
mouse_top 
mouse_bottom
mouse_wheel
mouse_wheel_braces

#pcb
you can view or the edit the pcb using ki cad 
the pcb file name is mouse_pcb.kicad_pcb

#the required item:
required item are listed in BOM through which you can also check the prices of electronics and where to get them.

#Frimware:
the frimware is written using c language file name is mouse_frimware.h
step to flash frimware :
Hold BOOTSEL button
Plug into PC
It shows as a USB drive
Compile your code → get .uf2 file
Drag & drop .uf2 into Pico

i made this project i was in need of good mouse and i will learn too so why to use my project you can get pcb and 3d print all stl and flash the frimware and use the usb to male connector to use it to your computer.

## KiCad design PCB/mouse_pic.kicad_pcb

Board: 2 copper layers, 49.8 x 61.7 mm, 67 parts (0 on the bottom side), 62 nets.

Parts:
C1, C2: 10uF; C_0603_1608Metric
C3: 100nF; C_0603_1608Metric
C4: 4.7uF; C_0603_1608Metric
C6, C7, C9, C11, C12, C13, C14, C15, C500: 100n; C_0603_1608Metric
C8, C10: 1u; C_0603_1608Metric
C100, C400: 10u; C_0603_1608Metric
C200, C300: 15p; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: D; D_SOD-123
Encoder1: RotaryEncoder; Alps-EC10E1220501
P11, P12, P13, P14, P15, P20, P21, P26, P27, P28, P29, P30, P31, P32: TestPoint; TestPoint_Pad_D1.0mm
R1: 10K; R_0603_1608Metric
R3, R4: 27; R_0603_1608Metric
R40: R39; R_0603_1608Metric
R100, R500: 1k; R_0603_1608Metric
R200: 10k; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6: SW_SPDT; SW_Tactile_SPDT_Omron_D2F
U1: LM1117-1.8V; SOT-223-3_TabPin2
U2: PMW3360DM-T2QU; PixArt_PDIP-16_10.9x16.2mm_P1.78mm
U3: RP2040; RP2040-QFN-56
U4: W25Q32JVSS; SOIC-8_5.275x5.275mm_P1.27mm
U10: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
USB1: USB; PinHeader_1x04_P2.54mm_Vertical
USB_BOOT1: Conn_01x01_Socket; TestPoint_THTPad_D2.0mm_Drill1.0mm_Edit
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C1.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C400.1, C500.1, R1.2, R200.1, U1.3 (VI), U2.5 (VDDIO), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.8 (VCC), U10.2 (VO)
/3360LED: R40.1, U2.15 (LED_P)
/ENC_A: Encoder1.A, U3.11 (GPIO8)
/ENC_B: Encoder1.B, U3.13 (GPIO10)
/ENC_C: Encoder1.C, U3.12 (GPIO9)
/GPIO0: D1.1 (K), D3.1 (K), D5.1 (K), D7.1 (K), D9.1 (K), D11.1 (K), U3.2 (GPIO0)
/GPIO1: D2.1 (K), D4.1 (K), D6.1 (K), D8.1 (K), D10.1 (K), D12.1 (K), U3.3 (GPIO1)
/GPIO2: SW1.2 (B), U3.4 (GPIO2)
/GPIO3: SW2.2 (B), U3.5 (GPIO3)
/GPIO4: SW3.2 (B), U3.6 (GPIO4)
/GPIO5: SW4.2 (B), U3.7 (GPIO5)
/GPIO6: SW6.2 (B), U3.8 (GPIO6)
/GPIO7: SW5.2 (B), U3.9 (GPIO7)
/GPIO11: P11.1, U3.14 (GPIO11)
/GPIO12: P12.1, U3.15 (GPIO12)
/GPIO13: P13.1, U3.16 (GPIO13)
/GPIO14: P14.1, U3.17 (GPIO14)
/GPIO15: P15.1, U3.18 (GPIO15)
/GPIO16: R1.1, U2.12 (MISO), U3.27 (GPIO16)
/GPIO17: U2.13 (NCS), U3.28 (GPIO17)
/GPIO18: U2.10 (SCLK), U3.29 (GPIO18)
/GPIO19: U2.11 (MOSI), U3.30 (GPIO19)
/GPIO20: P20.1, U3.31 (GPIO20)
/GPIO21: P21.1, U3.32 (GPIO21)
/GPIO26_ADC0: P26.1, U3.38 (GPIO26_ADC0)
/GPIO27_ADC1: P27.1, U3.39 (GPIO27_ADC1)
/GPIO28_ADC2: P28.1, U3.40 (GPIO28_ADC2)
/GPIO29_ADC3: P29.1, U3.41 (GPIO29_ADC3)
/QSPI_SCLK: U3.52 (QSPI_SCLK), U4.6 (CLK)
/QSPI_SD0: U3.53 (QSPI_SD0), U4.5 (DI(IO0))
/QSPI_SD1: U3.55 (QSPI_SD1), U4.2 (DO(IO1))
/QSPI_SD2: U3.54 (QSPI_SD2), U4.3 (IO2)
/QSPI_SD3: U3.51 (QSPI_SD3), U4.7 (IO3)
/QSPI_SS: R100.1, R200.2, U3.56 (QSPI_SS), U4.1 (~CS)
/RUN: P30.1, U3.26 (RUN)
/SWCLK: P31.1, U3.24 (SWCLK)
/SWD: P32.1, U3.25 (SWD)
/USBD+: R3.1, USB1.3
/USBD-: R4.1, USB1.2
/V2: C2.1, R40.2, U1.2 (VO), U2.4 (VDD)
/VDDPIX: C3.1, C4.1, U2.3 (VDDPIX)
/XIN: C200.1, U3.20 (XIN), Y1.1
/XOUT: R500.1, U3.21 (XOUT)
/~USB_BOOT: R100.2, USB_BOOT1.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C100.2, C200.2, C300.2, C400.2, C500.2, U1.1 (GND), U2.8 (GND), U3.19 (TESTEN), U3.57 (GND), U4.4 (GND), U10.1 (GND), USB1.1, Y1.2, Y1.4
unnamed: C300.1, R500.2, Y1.3
unnamed: D1.2 (A), SW1.1 (A)
unnamed: D2.2 (A), SW1.3 (C)
unnamed: D3.2 (A), SW2.1 (A)
unnamed: D4.2 (A), SW2.3 (C)
unnamed: D5.2 (A), SW3.1 (A)
unnamed: D6.2 (A), SW3.3 (C)
unnamed: D7.2 (A), SW4.1 (A)
unnamed: D8.2 (A), SW4.3 (C)
unnamed: D9.2 (A), SW5.1 (A)
unnamed: D10.2 (A), SW5.3 (C)
unnamed: D11.2 (A), SW6.1 (A)
unnamed: D12.2 (A), SW6.3 (C)
unnamed: R4.2, U3.46 (USB_DM)
unnamed: R3.2, U3.47 (USB_DP)
VBUS: C100.1, U10.3 (VI), USB1.4

## Commit log

2026-03-21 Enhance README with project details and requirements
    Expanded project description and added details about PCB, required items, and firmware.
2026-03-21 clean
    Removed copyright notice and comments for brevity.
2026-03-21 Update README with firmware flashing steps
    Added instructions for flashing firmware to README.
2026-03-22 complete readme
    Added a personal note about the project and its purpose.
2026-03-22 steps file
2026-03-22 Rename mouse_bottom.step to stepfile/mouse_bottom.step
2026-03-22 Rename mouse_thumb_a.step to stepfile/mouse_thumb_a.step
2026-03-22 Rename mouse_thumb_b.step to stepfile/mouse_thumb_b.step
2026-03-22 Rename mouse_top1.step to stepfile/mouse_top1.step
2026-03-22 Rename mouse_wheel.step to stepfile/mouse_wheel.step
2026-03-22 Rename mouse_wheel_braces.step to stepfile/mouse_wheel_braces.step
2026-03-22 Rename mouse_pic-brd.svg to mouseSS/mouse_pic-brd.svg
2026-03-22 Rename mouse_pic.svg to mouseSS/mouse_pic.svg
2026-03-22 Rename BOM.csv to BOM/BOM.csv
2026-03-22 Rename whole_mouse to mouseSS/whole_mouse
2026-03-22 Add files via upload
    cart picture wihout pcb
2026-03-22 Rename Screenshot 2026-03-22 180636.png to BOM/Screenshot 2026-03-22 180636.png
2026-03-22 Rename mouse_frimware.h to Frimware/mouse_frimware.h
2026-03-22 Add files via upload
    pcb board
2026-03-22 Rename mouse_pic.kicad_pcb to PCB/mouse_pic.kicad_pcb
